# Keil uVision project bcar.uvprojx, settings and files
target bcar (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: bcar +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../bsp;../drivers;../middleware;../control;../app;../src/bsp;../src/drivers;../src/middleware;../src/control;../src/app
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group src/bsp
    ../src/bsp/: bsp_afio.c bsp_gpio.c bsp_systick.c
  group src/drivers
    ../src/drivers/: adc_ir.c buzzer.c encoder.c imu660.c key.c led.c motor.c uart_dbg.c
  group src/middleware
    ../src/middleware/: heading.c lapstat.c line_pos.c odom.c p2quant.c zebra.c
  group src/control
    ../src/control/: angle_pd.c control.c mixer.c straight.c
  group src/app
    ../src/app/: cmdline.c fsm.c launch.c str_util.c telemetry.c
software components: CMSIS:CORE 4.3.0
